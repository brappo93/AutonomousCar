# Keil uVision project ee192-sp14.uvprojx, settings and files
target mbed FRDM-KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ee192-sp14
  AfterMake: fromelf --bin -o build\ee192-sp14_KL25Z.bin build\ee192-sp14.axf
  c flags: Optim=1
  c define: TARGET_KL25Z,  TARGET_M0P,  TARGET_Freescale,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0PLUS,  ARM_MATH_CM0PLUS, __MBED__,
  c misc: --gnu
  c include: .;  mbed;  mbed/TARGET_KL25Z;  mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD; mbed-rtos;  mbed-rtos/rtx;  mbed-rtos/rtx/TARGET_M0P;  mbed-rtos/rtx/TARGET_M0P/TOOLCHAIN_ARM;  mbed-rtos/rtos; MODSERIAL;  MODSERIAL/Device
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/system_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/startup_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
    ./server-cpp/: telemetry.h packet.cpp protocol.cpp telemetry.cpp telemetry-arduino-hal.cpp telemetry-data.cpp telemetry-mbed-hal.cpp packet.h protocol.h queue.h telemetry-arduino-hal.h telemetry-hal.h telemetry-mbed-hal.h
    ./PID/: PID.cpp
  group Infrastructure
    ./mbed-rtos/rtx/TARGET_M0P/TOOLCHAIN_ARM/: HAL_CM0.c SVC_Table.s
    ./mbed-rtos/rtx/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_Mutex.c rt_MemBox.c rt_Robin.c rt_System.c rt_Semaphore.c rt_Task.c RTX_Conf_CM.c rt_Time.c os_tcb.h cmsis_os.h rt_Event.h rt_HAL_CM.h rt_Mailbox.h rt_List.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf.h
    ./mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h RtosTimer.cpp Thread.h RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp
    ./MODSERIAL/: FLUSH.cpp GETC.cpp INIT.cpp ISR_RX.cpp ISR_TX.cpp MACROS.h MODSERIAL.h PUTC.cpp RESIZE.cpp
  group MODSERIAL
    ./MODSERIAL/Device/: MODSERIAL_KL25Z.cpp MODSERIAL_LPC1768.cpp MODSERIAL_LPC11U24.cpp
    ./MODSERIAL/: MODSERIAL_IRQ_INFO.cpp MODSERIAL.cpp
software components: CMSIS:CORE 4.3.0
