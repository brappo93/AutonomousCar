# Keil uVision project FastAnalogIn.uvproj, settings and files
target mbed FRDM-KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: FastAnalogIn
  AfterMake: fromelf --bin -o build\FastAnalogIn_KL25Z.bin build\FastAnalogIn.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_KLXX,  TARGET_KL25Z,  MBED_BUILD_TIMESTAMP=1460411021.28,  TARGET_CORTEX_M,  TARGET_LIKE_MBED,  TARGET_M0P,  TARGET_Freescale,  TOOLCHAIN_ARM_STD,  __MBED__=1,  __CORTEX_M0PLUS,  TOOLCHAIN_ARM,  TARGET_LIKE_CORTEX_M0,  ARM_MATH_CM0PLUS,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: None
  group src
    ./: FastAnalogIn_KLXX_K20D50M.cpp FastAnalogIn_LPC11UXX.cpp FastAnalogIn_LPC1768.cpp FastAnalogIn_LPC408X.cpp
